# Keil uVision project LED.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\LCD12864;..\HARDWARE\FPGASPI;..\HARDWARE\DAC;..\HARDWARE\DAC8560;..\HARDWARE\Relay;..\HARDWARE\Timer;..\HARDWARE\Flash;..\HARDWARE\TFTLCD;..\HARDWARE\KeyBoard;..\HARDWARE\ADS1118;..\HARDWARE\AD9854;..\TASK\GUITask.h
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LCD12864/: LCD12864.c
    ../HARDWARE/FPGASPI/: FPGASPI.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/Relay/: Relay.c
    ../HARDWARE/DAC8560/: DAC8560_Driver.c
    ../HARDWARE/PID/: pid.c
    ./: filter.c PulseMeter.c
    ../HARDWARE/Flash/: stmflash.c
    ../HARDWARE/KeyBoard/: KeyBoard.c
    ../HARDWARE/ADS1118/: ADS1118_SPI.c
    ../HARDWARE/AD9854/: AD9854.c
    ../HARDWARE/TFTLCD/: lcd.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dac.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_exti.c
  group TASK
    ../Task/: GUITask.c
  group README
    ../: readme.txt
software components: USB:CORE 6.2.0
